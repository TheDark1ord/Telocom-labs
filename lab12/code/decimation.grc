options:
  parameters:
    author: Barry Duggan
    generate_options: qt_gui
    id: RTTY_receive
    output_language: python
    title: RTTY_receive
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 1/0.022
  states: {}
- name: center
  id: variable
  parameters:
    value: '2210'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '170'
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '1'
    option1: '-1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-70'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: sq_lvl
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: sample rate 960 Hz
    gain: samp_rate/(2*math.pi*fsk_deviation*decim)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normal/Reverse
    const: reverse
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,1000,400)
    type: fcf
  states: {}
- name: note_0
  id: note
  parameters:
    note: revised 04 Apr 2024
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: Decimated Signal
    size: '512'
    srate: '500'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: Microphone input
    size: samp_rate
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      sample rate = 500 yields
      11 samples per symbol
    decim: '960'
    interp: '500'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [audio_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
